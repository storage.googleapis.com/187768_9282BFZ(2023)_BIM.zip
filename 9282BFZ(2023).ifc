Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-06-14T17:20:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 14 17:20:21 2023 * Host: DESKTOP-4UM54TC * Database: C:\Users\Vlad\AppData\Local\Temp\759ee022-3bab-4bb7-b5d6-2821236c801b\97a73023-276c-400e-85b0-8447be3542cc\ifc * Database version: 5507 * Database creation date: Wed Jun 14 17:20:20 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 14 17:20:20 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 14 17:20:20 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 9282BFZ Washbasin faucet, Bluetooth, 9282BFZ(2023):9282BFZ Washbasin faucet, Bluetooth:334603
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - FaucetNominalDepth: 168 mm; FaucetNominalHeight: 135 mm; FaucetNominalWidth: 55 mm; HandShowerNominalDepth: 68.5 mm; HandShowerNominalHeight: 316.8 mm; HandShowerNominalWidth: 57 mm; InletConnectionSize: 10 mm
Type - Electrical - Battery: LS17500 A Li-SOCl2 Lithium 3.6V; Bluetooth: 5.x (D060576); Operating Voltage: 0 V; Protection Class: IP 55
Type - General - Author: BIMStone; BIMObjectName: 9282BFZ(2023); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 01/06/2023
Type - Green Building Properties - EAN Number: 6414150102905; EMC Directive: 2014/53/EU , 2011/65/EU; ETIM Class Number: EC010340 Electronic tap; LVI Number: 6110439; NRF Number: 4203746; RSK Number: 8430046; Sales Package dimensions (LxWxH): 568 x 182 x 78; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/9282BFZ; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL Materials Declaration: http://www.oras.com/fileadmin/resources/183282_9282BFZ_materialsdeclaration.pdf; URL REACH: http://static.oras.com/doc/reach; URL WEEE: http://static.oras.com/WEEE/9282BFZ; VVS Number: 704282804
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/9282BFZ; Catalog Drawing URL: http://static.oras.com/catdrw/9282BFZ; Dimension Drawing URL: http://static.oras.com/dimdrw/9282BFZ; FDV Document URL: http://www.oras.com/datasheet/9282BFZ/en/fdv; Group: Washbasin faucet; Long Marketing: Electra 92 series give you a clean classic design with beautiful round body flowing into round spout design with a clear design line framing the faucet design. A Classic design for any installation. Key Features Aerator with Tilt function +/- 10° for more flexible installation Newest Sensor technology for better detection and operation comfort Bluetooth technology for easy adjustment to personalize settings Antiscalding protection Temperature measurement Bluetooth Remote bidetta Digital Network Service Digital power module; Manufacturer: Oras; Market: International;Finland;Norway; Mobile Product Information URL: http://mpi.oras.com/9282BFZ; Model: 9282BFZ Washbasin faucet, Bluetooth; Name_en: 9282BFZ Washbasin faucet, Bluetooth; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 9282BFZ; Product Family: Oras Electra; Product Image URL: http://static.oras.com/image/9282BFZ; Product URL: http://static.oras.com/9282BFZ; Technical DataSheet URL: http://www.oras.com/datasheet/9282BFZ/en; Type Name: 9282BFZ Washbasin faucet, Bluetooth; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Inner body made of DZR brass;3S-installation system for safe and simple mounting; Aerator: PCA® - constant flow rate regardless of pressure variations;Adjustable flow angle; Afterflow Period: 3 s (1-20 s); Automatic Flush Frequency: off (off/1-120 h); Automatic Flush Period: 30 s (1-1800 s); Connection: Flexible inlet pipes; Electronic Parts: ;Light indicated function(s);Low battery indicator; Hand Shower: Bidetta hand shower; Installation Type: Deck mounted; Lever Handle: Hot/Cold symbols; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 2 min (1 - 1800 s); Mounting Holes: 1 hole; Operating Distance: 20-130 mm (110/130/160 mm); Shower Parts: Shower holder;Shower hose (1500 mm); Spout Type: Fixed spout; Surface treatment: Chrome; Temperature Adjustments: Adjustable hot water stop (included, retrofittable)
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 9282BFZ(2023); Features: Touchless;Bidetta;Self-powered;Bluetooth®; Finish: Polished; Grade: n/a; ModelNumber: n/a; ModelReference: 9282BFZ; Name: 9282BFZ Washbasin faucet, Bluetooth; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet:50x155x175 mm / Hand shower: 55x70x315 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DistanceX-Axis: 100 mm; DistanceY-Axis: 100 mm; Elevation from Level: 0 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; Hand Shower Visibility: yes; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.0841008 m2; Volume: 0.00248884 m3
Identity Data - Mark: 16
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 9282BFZ(2023): 9282BFZ Washbasin faucet, Bluetooth; Family and Type: 9282BFZ(2023): 9282BFZ Washbasin faucet, Bluetooth; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 9282BFZ(2023): 9282BFZ Washbasin faucet, Bluetooth; Type Id: 9282BFZ(2023): 9282BFZ Washbasin faucet, Bluetooth; WarrantyStartDate: n/a
Phasing - Phase Created: Phase 1
